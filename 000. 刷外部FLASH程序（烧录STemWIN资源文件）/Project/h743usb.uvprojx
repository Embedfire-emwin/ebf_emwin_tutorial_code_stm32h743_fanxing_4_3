# Keil uVision project h743usb.uvprojx, settings and files
target h743usb (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: h743usb +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_HAL_DRIVER,STM32H743xx
  c include: ..\User;..\Libraries\STM32H7xx_HAL_Driver\Inc;..\Libraries\CMSIS\Include;..\User\STM32_USB_Host_Library\Class\MSC\Inc;..\User\STM32_USB_Host_Library\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group STARTUP
    ./: startup_stm32h743xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group STM32H7xx_HAL_Driver
    ../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_dac.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sdram.c stm32h7xx_hal_spi.c stm32h7xx_hal_tim.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_ll_usb.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pwr_ex.c
  group USER
    ../User/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c usb_host.c usbh_conf.c
    ../User/flash/: bsp_spi_flash.c
    ../User/key/: bsp_key.c
    ../User/res_mgr/: res_reader.c res_writer.c
  group FatFs
    ../User/FATFS/: diskio.c ff.c
    ../User/FATFS/option/: cc936.c
  group USB_LIB
    ../User/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../User/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
software components: CMSIS:CORE 4.3.0
