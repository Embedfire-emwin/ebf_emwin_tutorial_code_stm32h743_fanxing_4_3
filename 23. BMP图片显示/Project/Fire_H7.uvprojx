# Keil uVision project Fire_H7.uvprojx, settings and files
target Fire_H7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: USBOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,OS_SUPPORT,__TARGET_FPU_VFP
  c include: ..\FreeRTOS\Source\CMSIS_RTOS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Libraries\STM32H7xx_HAL_Driver\Inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\STemWIN\inc;..\STemWIN\Config;..\STemWIN_Task;..\User;..\User\FATFS;..\User\STM32_USB_Host_Library\Core\Inc;..\User\STM32_USB_Host_Library\Class\MSC\Inc;..\User
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group STM32H7xx_HAL_Driver
    ../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_mdma.c
  group USER
    ../User/: freertos.c main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
    ../User/lcd/: bsp_ili9806g_lcd.c
    ../User/usart/: bsp_usart.c
    ../User/touch/: bsp_i2c_touch.c gt9xx.c
    ../User/mpu/: bsp_mpu.c
    ../User/led/: bsp_led.c
  group FreeRTOS/src
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group STemWin
    ../STemWIN/Config/: GUIConf.c GUIConf.h LCDConf_FlexColor.c
    ../STemWIN/OS/: GUI_X_OS.c
    ../STemWIN/Lib/: STemWin_CM7_OS_wc16_ot_ARGB.a
  group STemWin/Task
    ../STemWIN_Task/: MainTask.c
  group FatFs
    ../User/FATFS/: diskio.c ff.c
    ../User/FATFS/option/: cc936.c
  group USB_Host
    ../User/: usb_host.c usbh_conf.c
    ../User/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../User/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
software components: CMSIS:CORE 4.3.0
